<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ad9938dds.ewp</path>
  </project>
  <batchBuild />
</workspace>
